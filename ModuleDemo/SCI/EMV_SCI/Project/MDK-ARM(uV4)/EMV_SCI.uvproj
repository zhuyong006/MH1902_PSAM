# Keil uVision project EMV_SCI.uvproj, settings and files
target RAM (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: TestSCI +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,ARM_MATH_CM3
  c misc: --enum_is_int
  c include: ..\..\..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\..\..\Libraries\MHSCPU_Driver\inc\emvlib;..\..\..\..\..\Libraries\MHSCPU_Driver\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\..\User;..\..\User\emv_lib
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xa000
  group User
    ../../User/: main.c uart.c test_emv.c test_loopback.c
  group MDK-ARM
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../../../../../Libraries/MHSCPU_Driver/src/: misc.c mhscpu_sysctrl.c mhscpu_gpio.c mhscpu_emv_hard.c
    ../.././../../../Libraries/MHSCPU_Driver/src/: mhscpu_uart.c
  group CMSIS
    ../../../../../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group EMV_L1_Lib
    ../../../../../Libraries/MHSCPU_Driver/lib/: mh1902_emv.lib
target RAM-JLINK (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\MHSCPU_Driver\inc;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
